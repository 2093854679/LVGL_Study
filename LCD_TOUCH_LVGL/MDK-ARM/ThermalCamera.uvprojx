# Keil uVision project ThermalCamera.uvprojx, settings and files
target ThermalCamera (6210000::V6.21::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ThermalCamera +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/LCD;../BSP/mlx90640;../SYSTEM;../BSP/IIC;../BSP/TOUCH;../BSP/KEY;../MIDWare/lvgl;../MIDWare/lvgl/examples/porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/BSP
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/IIC/: iic_hal.c
    ../BSP/TOUCH/: CST816.c
    ../BSP/KEY/: key.c
  group Application/User/System
    ../SYSTEM/: delay.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MIDWare/lvgl/src
    ../MIDWare/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../MIDWare/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../MIDWare/lvgl/src/extra/: lv_extra.c
    ../MIDWare/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c
    ../MIDWare/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../MIDWare/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../MIDWare/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../MIDWare/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../MIDWare/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../MIDWare/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../MIDWare/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../MIDWare/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../MIDWare/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../MIDWare/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../MIDWare/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../MIDWare/lvgl/src/extra/widgets/led/: lv_led.c
    ../MIDWare/lvgl/src/extra/widgets/list/: lv_list.c
    ../MIDWare/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../MIDWare/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../MIDWare/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../MIDWare/lvgl/src/extra/widgets/span/: lv_span.c
    ../MIDWare/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../MIDWare/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../MIDWare/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../MIDWare/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../MIDWare/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../MIDWare/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../MIDWare/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../MIDWare/lvgl/src/extra/widgets/win/: lv_win.c
  group MIDWare/porting
    ../MIDWare/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
software components: CMSIS:CORE 6.0.0
